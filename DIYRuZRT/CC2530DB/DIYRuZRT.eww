<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DIYRuZRT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DIYRuZRT</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>DIYRuZRT</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>DIYRuZRT</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>DIYRuZRT</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


